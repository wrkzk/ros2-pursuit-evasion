Commit message: Change caster wheel position to rear

File: src/dd_robot/urdf/dd_robot.urdf (robot description, URDF)
Before this commit: robot dd_robot, 4 links, 3 joints
Joints:
- joint joint_caster: origin xyz=0.2 0 -0.125 rpy=0 0 0 -> xyz=-0.2 0 -0.125 rpy=0 0 0
